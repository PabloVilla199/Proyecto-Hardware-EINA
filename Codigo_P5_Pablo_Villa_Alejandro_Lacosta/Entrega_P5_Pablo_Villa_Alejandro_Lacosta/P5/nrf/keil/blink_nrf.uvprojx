# Keil uVision project blink_nrf.uvprojx, settings and files
target nRF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: blink_nrf +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10056 NRF52840_XXAA CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  __HEAP_SIZE=8192 __STACK_SIZE=8192
  c include: ../src_nrf;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  group Source Comun
    ../../src/: main.c drv_leds.c drv_leds.h drv_tiempo.c drv_tiempo.h hal_gpio.h hal_tiempo.h board.h rt_fifo.c rt_fifo.h drv_consumo.h drv_consumo.c rt_evento.h svc_logs.c svc_logs.h svc_alarmas.h drv_monitor.h drv_uart.h hal_uart.h test_blink_v2.h test_blink_v3.h test_fifo.h drv_monitor.c drv_uart.c test_blinkv2.c test_blinkv3.c test_fifo.c hal_consumo.h drv_botones.h drv_botones_test.h hal_ext_int.h hal_SC.h rt_GE.h svc_alarmas_test.h svc_GE.h drv_botones.c drv_botones_test.c rt_GE.c svc_alarmas.c svc_alarmas_test.c svc_GE.c blink.h blink.c bit_counter_strike.c bit_counter_strike.h drv_wdt.h test_wdt.c test_wdt.h hal_random.h beat_hero.h beat_hero.c beat_hero_extend.c test.h test.c
    ./: hal_wdt.h drv_wdt.c
  group Dependientes
    ../src_nrf/: hal_gpio_nrf.c hal_tiempo_nrf.c board_nrf52840dk.h board_nrf52840_dongle.h hal_uart_nrf.c hal_ext_int_nrf.c hal_SC_nrf.c hal_comsumo_nrf.c hal_random_nrf.c
    ./: hal_dwt_nrf.c
target NRF_PRODUCCION (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: blink_nrf +hex
  c flags: as above
  c define: BOARD_PCA10056 NRF52840_XXAA CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  __HEAP_SIZE=8192 __STACK_SIZE=8192 RUN_MODE=0 DEBUG=1
  c include: ../src_nrf;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
target NRF TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: blink_nrf +hex
  c flags: as above
  c define: BOARD_PCA10056 NRF52840_XXAA CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  __HEAP_SIZE=8192 __STACK_SIZE=8192 RUN_MODE=1 DEBUG=1
  c include: ../src_nrf;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
target NRF BLINK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: blink_nrf +hex
  c flags: as above
  c define: BOARD_PCA10056 NRF52840_XXAA CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  __HEAP_SIZE=8192 __STACK_SIZE=8192 RUN_MODE=2 DEBUG=0
  c include: ../src_nrf;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
target NRF BITCOUNTER (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: blink_nrf +hex
  c flags: as above
  c define: BOARD_PCA10056 NRF52840_XXAA CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  __HEAP_SIZE=8192 __STACK_SIZE=8192 RUN_MODE=3 DEBUG=1
  c include: ../src_nrf;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
software components: CMSIS:CORE 5.3.0, Device:Startup 8.44.1
