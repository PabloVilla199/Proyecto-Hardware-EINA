# Keil uVision project blink_lpc.uvproj, settings and files
target LPC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: blink_lpc
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LPC2105_simulador
  c include: ../../src;../src_lpc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Comun
    ../../src/: main.c drv_leds.c drv_leds.h drv_tiempo.c drv_tiempo.h hal_gpio.h hal_tiempo.h board.h blink.c drv_botones_test.c drv_uart.c svc_alarmas_test.c svc_logs.c test_blinkv2.c test_blinkv3.c test_fifo.c test_wdt.c test_wdt.h test_fifo.h test_blink_v3.h test_blink_v2.h svc_logs.h svc_alarmas_test.h hal_uart.h hal_random.h hal_consumo.h drv_uart.h drv_botones_test.h blink.h beat_hero.h beat_hero.c bit_counter_strike.c drv_botones.c drv_consumo.c drv_monitor.c drv_wtd.c rt_fifo.c rt_GE.c svc_alarmas.c svc_GE.c bit_counter_strike.h drv_botones.h drv_consumo.h drv_monitor.h drv_wdt.h hal_ext_int.h hal_SC.h hal_wdt.h rt_evento.h rt_fifo.h rt_GE.h svc_alarmas.h svc_GE.h beat_hero_extend.c
  group Dependientes
    ../src_lpc/: board_lpc.h hal_gpio_lpc.c hal_tiempo_lpc.c reserva_gpio_lpc2105.h hal_wdt_lpc.c hal_ext_int_lpc.c hal_consumo_lpc2105.c hal_random_lpc.c hal_uart_lpc.c
    ../../src/: hal_sc_lpc.c
  group Inicio
    ../src_lpc/: Startup.s
